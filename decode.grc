options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: receive
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bandwith
  id: variable_qtgui_range
  parameters:
    label: Reception bandwith (Hz)
    start: samp_rate / 100
    step: '1'
    stop: samp_rate / 2
    value: samp_rate / 100
  states: {}
- name: dc_offset_correction
  id: variable
  parameters:
    value: samp_rate / 4
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '50'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency (Hz)
    start: 433e6
    step: 1e3
    stop: 435e6
    value: 433920e3
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: freq -freq_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '2500'
    audio_stop: '5000'
    chan_rate: samp_rate/50
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-5'
    init: '0'
    low: '-4.9'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: 50e3/1.6e3
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate,50000, 1000, window.WIN_BLACKMAN, 6.76)
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '16'
    corr0: '20'
    freq0: freq_tune
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '28'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: freq
    fftsize: '1024'
    gui_hint: tabs@0
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@2
    label1: ''
    size: '1024'
    srate: samp_rate/50
    style1: '3'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tabs@1
    label1: ''
    size: '1024'
    srate: samp_rate/50
    tr_level: '-4.9'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev_args: driver=airspy,biastee=false
    devname: airspy
    overall_gain0: '26'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Original signal
    label1: Squared signal
    label2: Processed signal
    num_tabs: '3'
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_threshold_ff_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
