options:
  parameters:
    generate_options: qt_gui
    id: fmx_2
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0
    label: Frequency
    start: '0'
    step: '1'
    stop: '5000'
    value: '0'
  states: {}
- name: level
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0
    label: Level
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@0
    label: Mode
    label0: Norm
    label1: Cal
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '360000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@0
    label: Source
    label0: Tone
    label1: Audio
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: source_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: taps_up
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '7500'
    gain: '1.0'
    samp_rate: samp_rate
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: vco_sens
  id: variable
  parameters:
    value: '753982.2369'
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0
    label: Volume
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.2'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: '120000'
    deviation: '10000'
    gain: '1.0'
    tau: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: '1000'
    offset: '1'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: level
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: source_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '3'
    gain: '1'
    high_cutoff_freq: '140000'
    low_cutoff_freq: '100000'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: level*5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: source
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: vco_sens
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/dan/Downloads/sample.wav
    repeat: 'True'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 16 bit 48 khz WAV
  states: {}
- name: note_1
  id: note
  parameters:
    note: Tansmitter
  states: {}
- name: note_2
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: source_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_sink_x_0_0_2
  id: qtgui_sink_x
  parameters:
    bw: '24000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '15'
    taps: taps_up
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Baseband Audio
    label1: FM Output
    label2: Modulating Signal
    label3: FM Demodulated
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '102'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '101'
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '102'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0, '0', blocks_selector_0_0, '1']
- [analog_sig_source_x_1, '0', blocks_selector_0, '0']
- [band_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_selector_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '1']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0_0_2, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_selector_0_0, '0', blocks_vco_f_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0_0_1, '0']
- [blocks_throttle_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vco_f_0, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_vco_f_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', qtgui_sink_x_0_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0, '0']
- [virtual_source_2, '0', band_pass_filter_0, '0']

metadata:
  file_format: 1
