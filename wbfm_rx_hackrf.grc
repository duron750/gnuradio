options:
  parameters:
    author: danieltiganas
    generate_options: qt_gui
    id: wbfm_rx_hackrf
    output_language: python
    title: FM Radio
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Frequency
    start: '80'
    step: '0.1'
    stop: '108'
    value: '101'
  states: {}
- name: mod
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: tabs@0
    initPressed: 'False'
    label: stereo/mono
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: offset
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: RF Gain
    start: '0'
    step: '1'
    stop: '45'
    value: '28'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Volume
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: quadrature
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: quadrature
    tau: '50e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: quadrature
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '1'
    deemph_tau: '50e-6'
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: mod
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 60e3
    decim: int(samp_rate/quadrature)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '16'
    corr0: '20'
    freq0: freq*1e6+offset
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rf_gain
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: tabs@0
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: quadrature
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: tabs@1
    plotconst: 'False'
    plottime: 'False'
    plotwaterfall: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1000)
    interp: int(audio_rate/1000)
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: FFT Display
    label1: Band Display
    num_tabs: '2'
  states: {}

connections:
- [analog_fm_deemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_fm_deemph_0_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_wfm_rcv_pll_0, '0', analog_fm_deemph_0, '0']
- [analog_wfm_rcv_pll_0, '1', analog_fm_deemph_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_selector_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_selector_0_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_selector_0_0_0, '1']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_selector_0, '0', analog_wfm_rcv_pll_0, '0']
- [blocks_selector_0, '1', analog_wfm_rcv_0, '0']
- [blocks_selector_0_0, '0', audio_sink_0, '0']
- [blocks_selector_0_0_0, '0', audio_sink_0, '1']
- [low_pass_filter_0, '0', blocks_selector_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
