options:
  parameters:
    category: Custom
    description: Transmits NBFM from pc audio
    generate_options: qt_gui
    id: NBFM_XCVR
    output_language: python
    title: NBFM Transceiver
  states: {}

blocks:
- name: spike_freq
  id: variable
  parameters:
    value: 144e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '.75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 6e3
    quad_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '500'
    offset: '0'
    phase: '0'
    samp_rate: '48000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: spike_freq-rx_freq
    offset: '0'
    phase: '0'
    samp_rate: 8e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqch
  states: {}
- name: aud_gain
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 2,12,1,1
    label: TX Aud
    max: '100'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '20'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: aud_gain
    high_cutoff_freq: '3000'
    low_cutoff_freq: '200'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_aud*(-(rx_tx)+1)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: freq
  id: variable_slider
  parameters:
    converver: float_converter
    label: TX Frequency
    max: 146e6
    min: 144e6
    num_steps: '1000'
    style: wx.SL_HORIZONTAL
    value: 145.15e6
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: 300e-3*(rx_tx)
    samp_rate: '48000'
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_ccf
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: soapy=0,driver=lime
    bb_gain0: '0'
    freq0: freq
    gain0: rf_gain_tx*(rx_tx)
    if_gain0: '0'
    sample_rate: 8e6
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: soapy=0,driver=lime
    bb_gain0: '0'
    freq0: spike_freq+rx_freq_fine
    gain0: rf_gain_rx*(-(rx_tx)+1)
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: 8e6
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8000000'
    interp: '48000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '500'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rf_gain_rx
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,1,1,1
    label: RX Gain
    max: '40'
    min: '0'
    num_steps: '10'
    style: wx.SL_HORIZONTAL
    value: '40'
  states: {}
- name: rf_gain_tx
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 1,12,1,1
    label: TX Gain
    max: '60'
    min: '0'
    num_steps: '300'
    style: wx.SL_HORIZONTAL
    value: '40'
  states: {}
- name: rx_aud
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 2,1,1,1
    label: RX Aud
    max: '0.2'
    min: '0'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0.03'
  states: {}
- name: rx_freq
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 4,0,1,18
    label: RX Frequency
    max: 146e6
    min: 144e6
    num_steps: '200'
    style: wx.SL_HORIZONTAL
    value: 145.75e6
  states: {}
- name: rx_freq_fine
  id: variable_slider
  parameters:
    converver: float_converter
    label: RX  Freq. Fine
    max: 10e3
    min: '-10e3'
    num_steps: '100'
    style: wx.SL_HORIZONTAL
    value: '0'
  states: {}
- name: rx_tx
  id: variable_chooser
  parameters:
    choices: '[0, 1]'
    grid_pos: 0,8,1,1
    label: '    RX      TX'
    labels: '[''RX'', ''TX'']'
    style: wx.RA_HORIZONTAL
    type: radio_buttons
    value: '0'
  states: {}
- name: sqch
  id: variable_slider
  parameters:
    converver: float_converter
    grid_pos: 3,1,1,1
    label: RX Sqch
    max: '-50'
    min: '-110'
    num_steps: '20'
    style: wx.SL_HORIZONTAL
    value: '-80'
  states: {}
- name: wxgui_fftsink2_0_1
  id: wxgui_fftsink2
  parameters:
    average: 'True'
    avg_alpha: '0.4'
    baseband_freq: rx_freq+rx_freq_fine
    fft_rate: '10'
    fft_size: '512'
    freqvar: None
    peak_hold: 'False'
    ref_level: '-20'
    ref_scale: '2.0'
    samp_rate: '2000000'
    title: '            Receive  |  Spectrum'
    type: complex
    win: None
    win_size: 480,60
    y_divs: '9'
    y_per_div: '10'
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0_1, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0_1, '0', wxgui_fftsink2_0_1, '0']

metadata:
  file_format: 1
