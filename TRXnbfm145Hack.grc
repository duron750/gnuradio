options:
  parameters:
    author: danieltiganas
    generate_options: qt_gui
    id: nfm_tx
    output_language: python
    title: NFM TX Hackrf
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_dial_control
  parameters:
    label: Volum
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: int
    value: '0'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: '145785000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sqch
  id: variable_qtgui_dial_control
  parameters:
    label: Squelch
    maximum: '100'
    minimum: '0'
    showvalue: 'False'
    type: int
    value: '0'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '145185000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Gain
    start: '0'
    step: '0.1'
    stop: '47'
    value: '32'
    widget: counter
  states: {}
- name: variable_qtgui_chooser_0
  id: variable_qtgui_chooser
  parameters:
    label: '[''RX'', ''TX'']'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: rx_freq
    type: int
    value: rx_freq
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Mic Gain
    start: '0'
    step: '0.1'
    stop: '10'
    value: '3'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '48000'
    tau: '.75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: quadrature
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sqch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '200'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: quadrature
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tx_freq
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '2048'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadrature/1000)
    interp: int(samp_rate/1000)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: quadrature
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: soapy_airspyhf_source_0
  id: soapy_airspyhf_source
  parameters:
    agc: 'True'
    center_freq: rx_freq
    dev_args: driver=airspy
    lna: 'True'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: tx_freq
    dev_args: driver=hackrf
    samp_rate: samp_rate
    type: fc32
    vga: tx_gain
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_nbfm_tx_0, '0', low_pass_filter_1, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [audio_source_0, '0', blocks_throttle_0, '0']
- [band_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_airspyhf_source_0, '0', rational_resampler_xxx_0_0, '0']
- [soapy_airspyhf_source_0, '0', rational_resampler_xxx_0_1, '0']

metadata:
  file_format: 1
