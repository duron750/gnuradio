<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ssb_rx_v06_LF</value></param>
<param><key>author</key><value>OZ9AEC</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Simple SSB receiver prototype (LFRX)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>SSB Receiver V0.6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LO</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>agc_decay</value></param>
<param><key>choices</key><value>[100e-6, 50e-6, 10e-6]</value></param>
<param><key>value</key><value>50e-6</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>label</key><value>AGC</value></param>
<param><key>labels</key><value>['Fast', 'Medium', 'Slow']</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>50e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>center</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-1500</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Center</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>-5000</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7.1e6</value></param>
<param><key>grid_pos</key><value>1,0,1,3</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>14.5e6</value></param>
<param><key>min</key><value>3.5e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_tune</value></param>
<param><key>value</key><value>freq + lo_offset</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>high</value></param>
<param><key>value</key><value>center+width/2</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>200e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>label</key><value>Upconverter LO</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low</value></param>
<param><key>value</key><value>center-width/2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mix_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>8</value></param>
<param><key>grid_pos</key><value>4,2,1,1</value></param>
<param><key>label</key><value>Mix Gain</value></param>
<param><key>max</key><value>49.6</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>124</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Offset (coarse)</value></param>
<param><key>max</key><value>100000</value></param>
<param><key>min</key><value>-100000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Offset (fine)</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>trans</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>300</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Trans</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>min</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-30</value></param>
<param><key>num_steps</key><value>300</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>width</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>2600</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Width</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>0.1</value></param>
<param><key>decay_rate</key><value>agc_decay</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>2</value></param>
<param><key>reference</key><value>0.3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>high</value></param>
<param><key>low_cutoff_freq</key><value>low</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10**(1.*(volume+15)/10)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>-5</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-(offset_coarse+offset_fine)</value></param>
<param><key>decim</key><value>int(samp_rate/audio_rate)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, audio_rate, 25000, 2000, firdes.WIN_HAMMING, 6.76)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nbook</value></param>
<param><key>grid_pos</key><value>0,0,1,3</value></param>
<param><key>labels</key><value>['RF Spectrum', 'IF Spectrum']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq_tune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>mix_gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>airspy=0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>50</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>corr0</key><value>-65</value></param>
<param><key>freq0</key><value>freq_tune</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>rtl-0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>freq+LO</value></param>
<param><key>fft_size</key><value>768</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nbook,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>RF Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nbook,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>title</key><value>IF Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>1</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>grid_pos</key><value>5, 1, 1, 2</value></param>
<param><key>max_value</key><value>-10</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>S-Meter</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>dB</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_rms_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
