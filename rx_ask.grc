options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: 25e3
  states: {}
- name: channel_trans
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: data_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: tab@2:1,0
    label: Datarate
    type: int
    value: version_chooser
  states: {}
- name: data_rate_V1
  id: variable
  parameters:
    value: '680'
  states: {}
- name: data_rate_V2
  id: variable
  parameters:
    value: 510*2
  states: {}
- name: freq
  id: variable
  parameters:
    value: (0*433.886e6+0*433.877e6+0*433.995e6)+freq_range*1e6+100e3
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: freq_range
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@0:1,0
    label: Frequency
    min_len: '1'
    start: '433'
    step: '0.005'
    stop: '434'
    value: '433.915'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tab@1
    label: Decoder_Gain
    min_len: '1000'
    start: '0'
    step: '1'
    stop: '1000'
    value: '390'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: audio_rate/version_chooser
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: trans
  id: variable
  parameters:
    value: 1.2e3
  states: {}
- name: version_chooser
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tab@2:0,0
    label: Oregon Scientific Version
    labels: '["V1","V2"]'
    num_opts: '0'
    options: '[data_rate_V1, data_rate_V2]'
    type: raw
    value: data_rate_V2
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '0'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 0*500+1*2500
    audio_stop: '5000'
    chan_rate: samp_rate/50
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '-2500'
    samp_rate: samp_rate/50
    type: fir_filter_ccc
    width: trans
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: gain*1e-3
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/fifo
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/bjk/gnuradio/OregonScientific/oregonV2.wav
    format: FORMAT_WAV
    samp_rate: audio_rate
  states: {state: disabled}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '50'
    samp_rate: samp_rate
    taps: "firdes.low_pass(1, samp_rate, \rchannel_spacing,channel_trans, window.WIN_BLACKMAN, 6.76)"
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: TX/RX
    args: hackrf=0
    bb_gain0: '0'
    corr0: '20'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab@0:0,0
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tab@1:0,0
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/50
    fc: freq-freq_offset
    fftsize: '1024'
    gui_hint: tab@1
    showports: 'True'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: tab@0:2,0
    showports: 'True'
    type: complex
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Frequency
    label1: Signal
    label2: Datarate
    num_tabs: '3'
  states: {}

connections:
- [analog_agc2_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [analog_am_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [band_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_add_const_vxx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_file_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [osmosdr_source_0, '0', analog_agc2_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
